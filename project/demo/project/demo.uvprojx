# Keil uVision project demo.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32E103RB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: E103_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X, GD32E103_8M
  c include: ..\..\..\platform\gd32e10x;..\..\..\platform\gd32e10x\bsp;..\..\..\platform\gd32e10x\csp;..\..\..\platform\gd32e10x\csp\GD32E10x_standard_peripheral\inc;..\..\..\frame\inc;..\cfg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\demo.sct
  group app_main
    ../app/: app_main.c
    ../cfg/: rec_db.h app_driver_cfg.h app_cfg.h protocol_cmd_cfg.h app_def_param.h user_data_def.h
  group app_module
    ../../../app_module/: main.c protocol_ef2.c protocol_ef2_plus.c avg_filter.c
  group frame
    ../../../frame/src/: kfifo.c line_buf.c check_algorithm.c auto_reg_module.c hal_core.c tasks.c debug.c protocol_hal.c shell.c param_cfg.c rec_func_entity.c flash_part.c fsm.c cfm.c autotest.c
    ../../../frame/inc/: check_algorithm.h x_frame.h x_frame_cfg.h x_frame_typedefine.h auto_reg_module.h hal_core.h tasks.h debug.h protocol_hal.h shell.h param_cfg.h rec_func_entity.h rec_def.h flash_part.h fsm.h cfm.h autotest.h
  group driver
    ../../../driver/: driver_rtt.c systick_driver.c driver_gpio.c driver_uart.c
  group bsp
    ../../../platform/gd32e10x/bsp/: SEGGER_RTT.c bsp_systick.c bsp_gpio.c bsp_uart.c bsp_pwm.c bsp_adc.c
  group csp
    ../../../platform/gd32e10x/csp/: gd32e10x_it.c gd32e10x_it.h startup_gd32e10x.s system_gd32e10x.c system_gd32e10x.h
    ../../../platform/gd32e10x/csp/GD32E10x_standard_peripheral/src/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_can.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2
